PR .= ".1"

FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"
SRC_URI += "file://yajl-change-pkgconfig-dir.patch"
