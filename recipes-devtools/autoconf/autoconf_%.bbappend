PR .= ".1"

EXTRA_OECONF += "--infodir=${datadir}/${PN}/info"
