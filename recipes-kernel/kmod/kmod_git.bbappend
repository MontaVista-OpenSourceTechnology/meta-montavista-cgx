PR .=".1"
#FIXME not sure this is the right fix
#DEPENDS += "gnome-doc-utils-native"
