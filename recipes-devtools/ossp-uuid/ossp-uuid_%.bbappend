inherit multilib-alternatives

MULTILIB_ALTERNATIVES_${PN} = "${bindir}/uuid-config"
