SRC_URI += "file://atomic-ops-ilp32.diff"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"
