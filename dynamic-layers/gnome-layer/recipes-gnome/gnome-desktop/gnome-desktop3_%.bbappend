PR .= ".1" 
DEPENDS += "xkeyboard-config"
