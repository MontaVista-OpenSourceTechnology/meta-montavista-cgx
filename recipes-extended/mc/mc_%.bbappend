
inherit multilib-alternatives
MULTILIB_ALTERNATIVES_${PN} = "${libexecdir}/mc/extfs.d/iso9660 \
                              ${datadir}/mc/syntax/Syntax"
