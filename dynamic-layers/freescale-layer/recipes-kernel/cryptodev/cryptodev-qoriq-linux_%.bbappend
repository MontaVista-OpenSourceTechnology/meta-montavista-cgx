PR .= ".1"
COMPATIBLE_MACHINE:append = "|mx8"
