require devel-image.bb

export IMAGE_BASENAME = "default-image"
