require devel-image.bb

export IMAGE_BASENAME = "base-complete-image"
IMAGE_INSTALL += "packagegroup-additional-oe-tools"

