
#FIXME Need to create a test for use-ld and remove from native accordingly.
TARGET_CFLAGS_remove_class-native = "-fuse-ld=bfd"
TARGET_CXXFLAGS_remove_class-native = "-fuse-ld=bfd"
BUILD_CFLAGS_remove_class-native = "-fuse-ld=bfd"


