PR.=".2"
MAKEDUMPFILE = "makedumpfile"
MAKEDUMPFILE_mips = ""
MAKEDUMPFILE_mips64 = ""
MAKEDUMPFILE_aarch64 = ""
RDEPENDS_kdump += "${MAKEDUMPFILE}"
