inherit multilib-alternatives
MULTILIB_HEADERS = "urcu/config.h"

