inherit multilib-alternatives
MULTILIB_HEADERS = "check_stdint.h"

