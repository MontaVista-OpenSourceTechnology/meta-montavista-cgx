inherit multilib-alternatives
MULTILIB_HEADERS = "libol/olconfig.h"

