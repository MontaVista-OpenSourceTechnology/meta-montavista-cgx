PR .= ".1"
FULL_OPTIMIZATION_armv7a = ' -O0 -pipe -g -feliminate-unused-debug-types '
