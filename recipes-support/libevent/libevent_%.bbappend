inherit multilib-alternatives
MULTILIB_HEADERS = "event2/event-config.h"
