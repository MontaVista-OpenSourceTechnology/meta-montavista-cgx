inherit multilib-alternatives
MULTILIB_ALTERNATIVES_${PN} = "${bindir}/x11perfcomp"
