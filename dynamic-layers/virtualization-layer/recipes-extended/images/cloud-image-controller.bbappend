# openvswitch-controller has been renamed to openvswitch-testcontroller
IMAGE_INSTALL_remove = "openvswitch-controller"
IMAGE_INSTALL_append += " openvswitch-testcontroller "
