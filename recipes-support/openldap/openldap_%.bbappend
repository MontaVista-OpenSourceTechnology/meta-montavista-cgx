libexecdir = "${libdir}/${PN}"
