PR .= ".1"
CCARGS_append_virtclass-native = " -DNO_NIS "
AUXLIBS_append_virtclass-native = " -lresolv"
