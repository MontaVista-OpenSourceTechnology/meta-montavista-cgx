EXTRA_OEMAKE:append:class-nativesdk = " GIT_SUBMODULES_ACTION=ignore "
