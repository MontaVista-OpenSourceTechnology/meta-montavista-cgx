FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES = "file://psplash-mvista-img.h;outsuffix=default"
PR .= ".1"
SRC_URI[md5sum] = "1dba8879cd3ebb72b273c7ce3b1b71dc"
SRC_URI[sha256sum] = "30d45b571bb4dcc0473cb0c8302d201114ba97454016042d4934d300c7e9caa4"

