inherit multilib-alternatives
MULTILIB_HEADERS = "npth.h"

