inherit multilib-alternatives
MULTILIB_ALTERNATIVES_${PN} = "${bindir}/texi2any"
