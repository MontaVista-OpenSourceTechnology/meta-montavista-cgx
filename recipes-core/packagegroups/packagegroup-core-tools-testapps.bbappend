PR .= ".1"

KEXECTOOLS_powerpc := "kexec"

