inherit multilib-alternatives
MULTILIB_ALTERNATIVES_${PN}-dev_class-target = "${bindir}/nspr-config"
