inherit multilib-alternatives
MULTILIB_ALTERNATIVES_${PN} = "${bindir}/crossscripts/tclConfig.sh"
