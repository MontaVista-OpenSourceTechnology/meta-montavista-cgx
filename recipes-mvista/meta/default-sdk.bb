inherit meta
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/LICENSE;md5=3f40d7994397109285ec7b81fdeb3b58 \
                    file://${COREBASE}/meta/COPYING.MIT;md5=3da9cfbcb788c80a0384361b4de20420"


DEFAULT_SDK ?= "cge-complete-image"
do_build[depends] = "${DEFAULT_SDK}:do_populate_sdk"
