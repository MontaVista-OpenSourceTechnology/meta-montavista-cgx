CFLAGS += "-DNO_COROSYNC"
