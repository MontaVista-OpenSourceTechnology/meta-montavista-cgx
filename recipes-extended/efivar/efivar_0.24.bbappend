FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_virtclass-native += "file://centos6-build.diff"
