RDEPENDS_${PN}-runtime += "pam-plugin-loginuid pam-plugin-keyinit"

PR .= ".3"
