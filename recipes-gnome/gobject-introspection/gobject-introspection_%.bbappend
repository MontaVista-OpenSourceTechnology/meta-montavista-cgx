inherit multilib-alternatives
MULTILIB_ALTERNATIVES_${PN} = "${bindir}/g-ir-annotation-tool \
                               ${bindir}/g-ir-compiler-wrapper \
                               ${bindir}/g-ir-scanner \
                               ${bindir}/g-ir-scanner-lddwrapper \
                               ${bindir}/g-ir-scanner-qemuwrapper \
                               ${bindir}/g-ir-scanner-wrapper"

