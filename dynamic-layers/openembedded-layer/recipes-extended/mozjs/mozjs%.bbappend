require ${@bb.utils.contains('DISTRO_FEATURES', 'mvista-base', 'mozjs_mvista.inc', '', d)}
