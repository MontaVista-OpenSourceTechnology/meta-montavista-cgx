inherit multilib-alternatives
MULTILIB_HEADERS = "wireshark/config.h"

