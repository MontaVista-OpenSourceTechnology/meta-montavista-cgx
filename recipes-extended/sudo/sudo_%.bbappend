PR .= ".1"
libexecdir="${libdir}/${PN}"
mandir="${datadir}/${PN}/man"
