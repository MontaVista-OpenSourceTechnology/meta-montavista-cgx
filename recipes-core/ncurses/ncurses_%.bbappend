PR .= ".1"

BINCONFIG = "${bindir}/ncurses5-config ${bindir}/ncursesw5-config"
