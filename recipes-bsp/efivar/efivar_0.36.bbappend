FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI_append_class-native = " file://efivar-native.diff"


