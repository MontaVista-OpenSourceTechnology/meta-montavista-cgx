
inherit multilib-alternatives
MULTILIB_ALTERNATIVES_${PN} = "${sysconfdir}/man_db.conf"
