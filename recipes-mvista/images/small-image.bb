require recipes-core/images/core-image-minimal.bb
export IMAGE_BASENAME = "small-image"
