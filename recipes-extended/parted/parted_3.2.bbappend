#Parted customized to behave with installer  
PR .=".3"


FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#SRC_URI += "file://print-partition-type-in-machine-mode.patch \
#           file://mkpart-print-new-partition-number.patch \
#           file://fix-msdos-swap-flag.patch"


