PR .= ".1"

RDEPENDS_${PN}-ptest += "${PYTHON_PN}-pytz"
