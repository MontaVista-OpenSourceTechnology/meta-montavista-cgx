KORG_ARCHIVE_COMPRESSION = "xz"
DEFAULT_PREFERENCE = "-1"
require linux-libc-headers.inc

SRC_URI[md5sum] = "997c8492ebfdc9bb9e6ed8d4945539dd"
SRC_URI[sha256sum] = "c4c1a4841173aa572d79b7530db92ce493dbefe8049e6f461a46dd897df253f5"
