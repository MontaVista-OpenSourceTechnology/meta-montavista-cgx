FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://mips-dynamic-linker.patch"
