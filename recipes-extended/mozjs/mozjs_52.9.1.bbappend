inherit multilib-alternatives
MULTILIB_ALTERNATIVES_${PN} = "${bindir}/js52-config"
