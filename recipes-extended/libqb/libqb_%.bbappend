inherit remove-libtool
