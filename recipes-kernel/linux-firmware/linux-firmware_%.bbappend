PACKAGES += "${PN}-lic"

FILES_${PN}-lic += "${datadir}/licenses/${PN}/generic_*"
