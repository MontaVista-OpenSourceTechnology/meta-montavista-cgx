RDEPENDS:${PN}-ptest=" ${PN}   make diffutils gzip bash gawk coreutils procps   libgcc python3-core python3-io   "
