PR .= ".1"

RCONFLICTS_${PN} = ""
