SRC_URI += "file://findutils-missing-getrlimit.diff"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

