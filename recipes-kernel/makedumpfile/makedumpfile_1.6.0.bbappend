FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
PR.= ".1"
SRC_URI =+ "file://0001-PATCH-v2-Support-_count-_refcount-rename-in-struct-p.patch"
