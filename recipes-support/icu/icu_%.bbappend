inherit multilib-alternatives
MULTILIB_ALTERNATIVES_${PN}-dev = "${bindir}/icu-config"
