PR .= ".1"

EXTRA_OECONF_append_class-native = " --disable-libmount --disable-mount --disable-fsck"
