require recipes-core/images/core-image-base.bb

export IMAGE_BASENAME = "base-image"
