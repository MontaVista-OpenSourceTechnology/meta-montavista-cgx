FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
inherit multilib-alternatives
MULTILIB_HEADERS = "syslog-ng/syslog-ng-config.h"

