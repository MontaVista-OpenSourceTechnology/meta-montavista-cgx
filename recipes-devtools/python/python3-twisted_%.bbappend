PR .= ".1"

RDEPENDS_${PN}-bin += "${PN}-src"
