PR .= ".1"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://fix-failure-while-removing-package-using-dnf-for-armeb.patch"
