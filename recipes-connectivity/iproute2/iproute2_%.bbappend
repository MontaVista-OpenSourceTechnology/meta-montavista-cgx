# Copyright (c) 2012,2013 MontaVista Software, Inc.  All rights reserved.
#
# Released under the MIT license (see LICENSE.MIT for the terms)
#

PR .= ".1"

RRECOMMENDS_${PN} += "kernel-module-veth \
                     "

