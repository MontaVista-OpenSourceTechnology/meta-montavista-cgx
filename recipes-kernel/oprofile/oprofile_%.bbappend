PR .= ".1"

export mandir = "${datadir}/man/${PN}"
