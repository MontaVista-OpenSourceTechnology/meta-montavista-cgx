
do_configure[depends] += "virtual/kernel:do_build"
