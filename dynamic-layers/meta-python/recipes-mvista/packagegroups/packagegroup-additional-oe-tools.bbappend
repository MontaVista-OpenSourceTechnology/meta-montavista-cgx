RDEPENDS_packagegroup-oe-test-tools_append = " \
	python-pip \
"
