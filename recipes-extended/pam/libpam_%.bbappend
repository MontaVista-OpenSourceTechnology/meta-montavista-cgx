RDEPENDS_${PN}-runtime += "${MLPREFIX}pam-plugin-loginuid-${libpam_suffix} ${MLPREFIX}pam-plugin-keyinit-${libpam_suffix}"

PR .= ".1"
