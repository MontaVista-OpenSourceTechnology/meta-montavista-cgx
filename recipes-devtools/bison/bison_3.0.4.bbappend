PR .= ".1"

RDEPENDS_${PN} += "m4"
